File: Regulator/Regulator.kicad_pcb (KiCad board)
At the start: 2 copper layers, 6 parts, among them U1 LMR16006YQ3

Commit message: Tidy up
Parts:
- moved D1 0.07 mm to (2.28, 3.17)
